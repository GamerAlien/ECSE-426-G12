# Keil uVision project Base_Project.uvprojx, settings and files
target Lab 3 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Base_Project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx ,  __FPU_PRESENT=1 , HSE_VALUE=8000000, LSE_STARTUP_TIMEOUT=5000
  c include: .\Headers;.\Accelerometer\inc,.\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./Sources/: main.c fput_debug.c supporting_functions.c stm32f4xx_it.c accelerometer.c gpio.c
    ./: timer.c keyboard.c defines.h
    ./Headers/: accelerometer.h adc.h gpio.h main.h stm32f4xx_it.h supporting_functions.h timer.h
  group Accelerometer
    ./Accelerometer/src/: LIS3DSH.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:STM32Cube Framework:Classic 1.4.0, Device:STM32Cube HAL:ADC 1.4.0, Device:STM32Cube HAL:Common 1.4.0, Device:STM32Cube HAL:Cortex 1.4.0, Device:STM32Cube HAL:DMA 1.4.0, Device:STM32Cube HAL:Flash 1.4.0, Device:STM32Cube HAL:GPIO 1.4.0, Device:STM32Cube HAL:I2C 1.4.0, Device:STM32Cube HAL:I2S 1.4.0, Device:STM32Cube HAL:PWR 1.4.0, Device:STM32Cube HAL:RCC 1.4.0, Device:STM32Cube HAL:RTC 1.4.0, Device:STM32Cube HAL:SPI 1.4.0, Device:STM32Cube HAL:SRAM 1.4.0, Device:STM32Cube HAL:TIM 1.4.0, Device:STM32Cube HAL:UART 1.4.0, Device:STM32Cube HAL:USART 1.4.0, Device:Startup 2.4.2
